# Keil uVision project HRC_HostTest.uvprojx, settings and files
target HRC_HostTest (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32G474QBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: HRC_HostTest
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HRC_HOST_TEST
  c include: ../include;../../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: host_test.sct
  group Startup
    ./: startup_host.s
  group HRC Behavior Model
    ../src/: hrc_model.c hrc_host_hal.c system_host.c test_main.c pc_comm_host.c
  group Production HRC Code
    ../../Core/Src/: hrc_bus.c hrc_cfg.c hrc_test.c
